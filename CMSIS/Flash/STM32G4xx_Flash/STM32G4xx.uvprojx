# Keil uVision project STM32G4xx.uvprojx, settings and files
target STM32G47x-8x_512 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: STM32G47x-8x_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32G47x_512,DUAL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32G47x-8x_256 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G47x-8x_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32G47x_256,DUAL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G47x-8x_128 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G47x-8x_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32G47x_128,DUAL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G43x-4x_128 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G43x-4x_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32G43x_128
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G43x-4x_64 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G43x-4x_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32G43x_64
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G43x-4x_32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G43x-4x_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32G43x_32
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G49x-Ax_256 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G49x-Ax_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32G49x_256
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G49x-Ax_512 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G49x-Ax_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_MEM STM32G49x_512
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G4xx_SB_OPT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G4xx_SB_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_OPT FLASH_SB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32G4xx_DB_OPT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: STM32G4xx_DB_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 wLevel=2
  c define: FLASH_OPT FLASH_DB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
