# Keil uVision project STM32G474E-EVAL_QSPI.uvprojx, settings and files
target STM32G474E-EVAL_QSPI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: MT25QL512ABB_STM32G474E-EVAL
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32G474xx,USE_IOEXPANDER, CORE_CM4
  c include: ./;.\QSPI;..\..\..\Drivers\BSP\Components;..\..\..\Drivers\CMSIS\Core\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\..\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32G474E-EVAL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group QSPI
    ./QSPI/: STM32G4QSPI.c stm32g474e_eval_qspi.c stm32g4xx_hal_qspi.c
    ../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c
    ../../../Drivers/BSP/Components/mt25ql512abb/: mt25ql512abb.c
    ../../../Drivers/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
software components: CMSIS:CORE 5.4.0
